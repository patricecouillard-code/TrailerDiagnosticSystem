File: Canal_Left.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Add files via upload
Other:
- sheet Vehicule_Left ports: added none; removed Injection_Left_Fault
